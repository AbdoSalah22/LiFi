<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\lifi-transmitter\transmitter.ewp</path>
    </project>
    <batchBuild />
</workspace>
