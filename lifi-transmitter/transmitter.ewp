# IAR project transmitter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c startup_ewarm.c
  group HAL
    HAL/: BT.c BT.h LED.c LED.h ULTRASONIC.c ULTRASONIC.h
  group INC
    INC/: delay.c delay.h tm4c123gh6pm.h types.h
  group MCAL
    MCAL/: ADC.c ADC.h GPIO.c GPIO.h GPTM.c GPTM.h SYSTICK.c SYSTICK.h UART.c UART.h
